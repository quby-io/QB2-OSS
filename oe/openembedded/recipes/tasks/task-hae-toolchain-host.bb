require task-sdk-host.bb
PR = "r0"
DESCRIPTION = "Packages for a standalone HAE toolchain"
ALLOW_EMPTY = "1"

PACKAGES = "${PN}"

RDEPENDS_${PN} += "\
"
